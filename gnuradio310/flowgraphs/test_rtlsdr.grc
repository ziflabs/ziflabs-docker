options:
  parameters:
    author: HerrAmeise
    copyright: Zero-IF Labs, LLC
    description: simple spectrum analyzer for RTL-SDR
    generate_options: qt_gui
    id: test_rtlsdr
    output_language: python
    title: 'Test: RTL-SDR'
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency
    start: freq_low + (samp_rate/2)
    step: samp_rate/4
    stop: freq_high - (samp_rate/2)
    value: 1090e6
  states: {}
- name: freq_high
  id: variable
  parameters:
    value: 1.75e9
  states: {}
- name: freq_low
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,2
    label: Gain
    labels: '["0.0", "0.9", "1.4", "2.7", "3.7", "7.7", "8.7", "12.5", "14.4", "15.7", "16.6", "19.7", "20.7", "22.9", "25.4", "28.0", "29.7", "32.8", "33.8", "36.4", "37.2", "38.6", "40.2", "42.1", "43.4", "43.9", "44.5", "48.0", "49.6"]'
    num_opts: '0'
    options: '[0.0, 0.9, 1.4, 2.7, 3.7, 7.7, 8.7, 12.5, 14.4, 15.7, 16.6, 19.7, 20.7, 22.9, 25.4, 28.0, 29.7, 32.8, 33.8, 36.4, 37.2, 38.6, 40.2, 42.1, 43.4, 43.9, 44.5, 48.0, 49.6]'
    type: real
    value: '48.0'
  states: {}
- name: gui_update
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '8192'
    gui_hint: 2,0,1,1
    name: '"Spectrum"'
    type: complex
    update_time: gui_update
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '8192'
    gui_hint: 2,1,1,1
    name: '"Waterfall"'
    type: complex
    update_time: gui_update
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
