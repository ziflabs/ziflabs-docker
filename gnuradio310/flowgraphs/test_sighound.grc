options:
  parameters:
    author: HerrAmeise
    category: Custom
    copyright: Zero-IF Labs, LLC
    description: simple spectrum analyzer for Signal Hound BB60C
    generate_options: qt_gui
    id: test_signalhound
    output_language: python
    title: 'Test: Signal Hound BB60C'
  states: {}

blocks:
- name: decimation
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate (Decimation)
    labels: '["40 MS/s (1)","20 MS/s (2)","10 MS/s (4)","5 MS/s (8)","2.5 MS/s (16)","1.25 MS/s (32)","625 KS/s (64)","312.5 KS/s (128)","156.25 KS/s (256)","78.125 KS/s (512)","39,062.5 S/s (1024)","19,531.25 S/s (2048)","9,765.625 S/s (4096)","4,882.8125 S/s (8192)"]'
    num_opts: '0'
    options: '[1,2,4,8,16,32,64,128,256,512,1024,2048,4096,8192]'
    type: int
    value: '4'
  states: {}
- name: filter_bw
  id: variable
  parameters:
    value: '{1:27e6, 2:17.8e6, 4:8e6, 8:3.75e6, 16:2e6, 32:1e6, 64:0.5e6, 128:0.25e6, 256:140e3, 512:65e3, 1024:30e3, 2048:15e3, 4096:8e3, 8192:4e3}[decimation]'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency [Hz]
    start: 10e3
    step: 10e3
    stop: 6e9
    value: 2425e6
  states: {}
- name: gui_update
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: ref_level
  id: variable_qtgui_range
  parameters:
    label: Reference Level (dBm)
    start: '-80.0'
    step: '0.1'
    stop: '20.0'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6/decimation
  states: {}
- name: bb60_iq_1
  id: bb60_iq
  parameters:
    bandwidth: filter_bw
    center: freq
    decimation: decimation
    purge: 'False'
    reflevel: ref_level
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '8192'
    gui_hint: 4,0,1,1
    name: '"Spectrum"'
    type: complex
    update_time: gui_update
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '8192'
    gui_hint: 4,1,1,1
    name: '"Waterfall"'
    type: complex
    update_time: gui_update
  states: {}

connections:
- [bb60_iq_1, '0', qtgui_freq_sink_x_0, '0']
- [bb60_iq_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
