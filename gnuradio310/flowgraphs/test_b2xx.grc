options:
  parameters:
    author: HerrAmeise
    category: Custom
    copyright: Zero-IF Labs, LLC
    description: simple spectrum analyzer for USRP B2XX
    generate_options: qt_gui
    id: test_b2xx
    output_language: python
    title: 'Test: USRP B2XX'
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency
    start: freq_low + (samp_rate/2)
    step: 5e6
    stop: freq_high - (samp_rate/2)
    value: 2.45e9
  states: {}
- name: freq_high
  id: variable
  parameters:
    value: 6e9
  states: {}
- name: freq_low
  id: variable
  parameters:
    value: 70e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '55'
  states: {}
- name: gui_update
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '8192'
    gui_hint: 2,0,1,1
    name: '"Spectrum"'
    type: complex
    update_time: gui_update
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '8192'
    gui_hint: 2,1,1,1
    name: '"Waterfall"'
    type: complex
    update_time: gui_update
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
