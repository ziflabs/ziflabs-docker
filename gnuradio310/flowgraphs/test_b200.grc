options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test_b2xx
    output_language: python
    title: 'Test: USRP B2XX'
  states: {}

blocks:
- name: default_station
  id: variable
  parameters:
    comment: Rumba 106.1 Philadelphia
    value: '106.1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: station*1000000
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '55'
  states: {}
- name: gui_update
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {state: disabled}
- name: station
  id: variable_qtgui_range
  parameters:
    label: Station
    outputmsgname: value
    showports: 'False'
    start: '88.5'
    step: '0.2'
    stop: '107.9'
    value: default_station
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
    gui_hint: 1,0,1,4
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '8192'
    gui_hint: 1,0,1,4
    name: '"RF Spectrum"'
    type: complex
    update_time: gui_update
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '8192'
    gui_hint: 1,0,1,4
    name: '"RF Spectrum"'
    type: complex
    update_time: gui_update
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
