options:
  parameters:
    author: HerrAmeise
    copyright: Zero-IF Labs, LLC
    description: simple spectrum analyzer for SDRplay RSPxxx
    generate_options: qt_gui
    id: test_sdrplay
    output_language: python
    title: 'Test: SDRplay RSPxxx'
  states: {}

blocks:
- name: antenna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,0,1,2
    label: Antenna
    label0: '"Tuner 1 50 ohm"'
    label1: '"Tuner 1 Hi-Z"'
    label2: '"Tuner 2 50 ohm"'
    labels: '["62500", "96000", "125000", "192000", "250000", "384000", "500000", "768000", "1000000", "2000000", "2048000", "3000000", "4000000", "5000000", "6000000", "7000000", "8000000", "9000000", "10000000"]'
    num_opts: '3'
    option0: '"Tuner 1 50 ohm"'
    option1: '"Tuner 1 Hi-Z"'
    option2: '"Tuner 2 50 ohm"'
    options: '[62500, 96000, 125000, 192000, 250000, 384000, 500000, 768000, 1000000, 2000000, 2048000, 3000000, 4000000, 5000000, 6000000, 7000000, 8000000, 9000000, 10000000]'
    type: string
    value: '"Tuner 1 50 ohm"'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency
    start: freq_low + (samp_rate/2)
    step: samp_rate/4
    stop: freq_high - (samp_rate/2)
    value: 1090e6
  states: {}
- name: freq_high
  id: variable
  parameters:
    value: 2e9
  states: {}
- name: freq_low
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Gain
    start: '-47'
    step: '0.5'
    stop: '0'
    value: '-20'
  states: {}
- name: gui_update
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,2
    label: Sample Rate
    labels: '["62500", "96000", "125000", "192000", "250000", "384000", "500000", "768000", "1000000", "2000000", "2048000", "3000000", "4000000", "5000000", "6000000", "7000000", "8000000", "9000000", "10000000"]'
    num_opts: '0'
    options: '[62500, 96000, 125000, 192000, 250000, 384000, 500000, 768000, 1000000, 2000000, 2048000, 3000000, 4000000, 5000000, 6000000, 7000000, 8000000, 9000000, 10000000]'
    type: real
    value: '2048000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq
    fftsize: '8192'
    gui_hint: 4,0,1,1
    name: '"Spectrum"'
    type: complex
    update_time: gui_update
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '8192'
    gui_hint: 4,1,1,1
    name: '"Waterfall"'
    type: complex
    update_time: gui_update
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    antenna: antenna
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_sdrplay_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_sdrplay_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
